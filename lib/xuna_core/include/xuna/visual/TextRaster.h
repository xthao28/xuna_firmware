#pragma once
#include <cstddef>
#include <cstdint>
namespace xuna {
// Small anti-aliased bitmap text for device cards (Vietnamese included).
// Fonts are generated by tools/generate_ui_font.py: glyphs sorted by code
// point, 8-bit coverage, metrics relative to the baseline. On the ESP32 the
// tables live in memory-mapped Flash, so plain reads work.
struct UiGlyph {
  uint32_t codepoint;
  uint32_t offset;  // into UiFont::alpha
  uint8_t width, height;
  int8_t left, top;  // top is negative above the baseline
  uint8_t advance;
};
struct UiFont {
  const UiGlyph* glyphs;
  uint16_t count;
  const uint8_t* alpha;
  uint8_t ascent, lineHeight;
};
// RGB565 target (row-major, width × height); drawing is clipped to it.
struct Canvas {
  uint16_t* pixels;
  uint16_t width, height;
};

// Decodes one UTF-8 code point and advances `p`; malformed input yields
// U+FFFD and consumes one byte, so a loop always terminates.
inline uint32_t decodeUtf8(const char*& p) {
  const uint8_t c = uint8_t(*p);
  if (!c) return 0;
  ++p;
  if (c < 0x80) return c;
  const int extra = c < 0xC2 ? -1 : c < 0xE0 ? 1 : c < 0xF0 ? 2 : c < 0xF5 ? 3 : -1;
  if (extra < 0) return 0xFFFD;
  uint32_t cp = c & (0x3F >> extra);
  const char* q = p;
  for (int i = 0; i < extra; ++i, ++q) {
    const uint8_t n = uint8_t(*q);
    if ((n & 0xC0) != 0x80) return 0xFFFD;
    cp = (cp << 6) | (n & 0x3F);
  }
  p = q;
  return cp;
}

inline const UiGlyph* findGlyph(const UiFont& font, uint32_t cp) {
  uint16_t lo = 0, hi = font.count;
  while (lo < hi) {
    const uint16_t mid = uint16_t((lo + hi) / 2);
    if (font.glyphs[mid].codepoint < cp) lo = uint16_t(mid + 1);
    else hi = mid;
  }
  return lo < font.count && font.glyphs[lo].codepoint == cp ? &font.glyphs[lo] : nullptr;
}

// A missing glyph advances like a space (or 1/3 em if the font has none).
inline uint16_t advanceOf(const UiFont& font, uint32_t cp) {
  const UiGlyph* g = findGlyph(font, cp);
  if (g) return g->advance;
  const UiGlyph* space = findGlyph(font, ' ');
  return space ? space->advance : uint16_t(font.lineHeight / 3);
}

inline uint16_t textWidth(const UiFont& font, const char* text) {
  uint16_t width = 0;
  for (const char* p = text; *p;) width = uint16_t(width + advanceOf(font, decodeUtf8(p)));
  return width;
}

inline uint16_t blend565(uint16_t bg, uint16_t fg, uint8_t a) {
  if (a == 255) return fg;
  if (!a) return bg;
  const uint32_t r = (((fg >> 11) & 31) * a + ((bg >> 11) & 31) * (255 - a) + 127) / 255;
  const uint32_t g = (((fg >> 5) & 63) * a + ((bg >> 5) & 63) * (255 - a) + 127) / 255;
  const uint32_t b = ((fg & 31) * a + (bg & 31) * (255 - a) + 127) / 255;
  return uint16_t((r << 11) | (g << 5) | b);
}

inline void fillRect(Canvas& c, int x, int y, int w, int h, uint16_t color) {
  for (int yy = y < 0 ? 0 : y; yy < y + h && yy < c.height; ++yy)
    for (int xx = x < 0 ? 0 : x; xx < x + w && xx < c.width; ++xx)
      c.pixels[yy * c.width + xx] = color;
}

// Draws `text` with its baseline at y; returns the x after the last glyph.
inline int drawText(Canvas& c, const UiFont& font, int x, int baseline, const char* text,
                    uint16_t color) {
  for (const char* p = text; *p;) {
    const uint32_t cp = decodeUtf8(p);
    const UiGlyph* g = findGlyph(font, cp);
    if (!g) { x += advanceOf(font, cp); continue; }
    const uint8_t* a = font.alpha + g->offset;
    const int gx = x + g->left, gy = baseline + g->top;
    for (int yy = 0; yy < g->height; ++yy) {
      const int py = gy + yy;
      if (py < 0 || py >= c.height) continue;
      for (int xx = 0; xx < g->width; ++xx) {
        const int px = gx + xx;
        if (px < 0 || px >= c.width) continue;
        uint16_t& dst = c.pixels[py * c.width + px];
        dst = blend565(dst, color, a[yy * g->width + xx]);
      }
    }
    x += g->advance;
  }
  return x;
}
}
